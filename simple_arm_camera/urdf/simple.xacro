Commit message: fix invalid value

File: simple_arm_camera/urdf/simple.xacro (robot description, xacro)
@@ -194,5 +194,5 @@
       <origin xyz="0 0 0.03" rpy="0 0 0"/>
       <geometry>
-        <box size="0.05 0.05 0.0.5"/>
+        <box size="0.05 0.05 0.1"/>
       </geometry>
     </visual>
